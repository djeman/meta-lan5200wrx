# Append path for lan5200wrx to include custom machconfig
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
