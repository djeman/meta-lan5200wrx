FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://001-Revert-gdkseatdefault-Grab-touch-events-where-applic.patch"

