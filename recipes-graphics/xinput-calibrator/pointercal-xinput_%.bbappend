# Append path
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
